# Keil uVision project r2_m4_lcd.uvprojx, settings and files
target Master (6150000::V6.15::ARMCLANG)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: r2_m4_lcd +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c define: __DEBUG I2C_MASTER
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../../../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../source/: main.c i2c_master.c i2c_slave.c app_gpio.c app_pwm.c app_uart.c app_touch.c
  group driver
    ../../../driver/src/: ddl.c sysctrl.c i2c.c gpio.c uart.c pca.c
  group README
    ../: readme.txt
target Slave (6150000::V6.15::ARMCLANG)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: as above
  output: r2_m4_lcd +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c define: __DEBUG
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.4.0
